<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BluTechDevice_stm32l152_lightSensor.ewp</path>
  </project>
  <batchBuild />
</workspace>
